# Keil uVision project chaos_cortex_m3.uvprojx, settings and files
target debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: lib_chaos (library)
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\include;..\..\kernel\include;..\..\porting\cortex_m4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group kernel
    ../../kernel/: system.c
  group porting
    ../../porting/cortex_m3/: co_port_handler.c co_port_stack.c
target release (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: as above
  output: lib_chaos (library)
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\include;..\..\kernel\include;..\..\porting\cortex_m4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
